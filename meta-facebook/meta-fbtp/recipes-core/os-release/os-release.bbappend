#
# These file add version

# Machine name and BMC version for release
MACHINE_NAME = "Yosemite"
BMC_VERSION = "0.8.0"

# Replace PRETTY_NAME to add MACHINE_NAME and BMC_VERSION
PRETTY_NAME = "ITRenew ${MACHINE_NAME} ${BMC_VERSION} -- Base: ${DISTRO_NAME} ${VERSION}"
